# Keil uVision project Ruidi_RL78_Extender.uvproj, settings and files
target Ruidi_RL78_Extender (ARM-ADS)
  device: STM32F030C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Ruidi_RL78_Extender
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;          "C:/Users/James Sun/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Inc";          "C:/Users/James Sun/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy";          "C:/Users/James Sun/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS/Include";          "C:/Users/James Sun/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include"
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/James Sun/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_wwdg.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: stm32f0xx_it.c tim.c wwdg.c gpio.c adc.c stm32f0xx_hal_msp.c main.c usart.c eeprom.c Remote.c
  group Drivers/CMSIS
    C:/Users/James Sun/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
